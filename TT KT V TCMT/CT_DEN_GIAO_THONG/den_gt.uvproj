# Keil uVision project den_gt.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: den_gt +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: den_gt.c delay.c
