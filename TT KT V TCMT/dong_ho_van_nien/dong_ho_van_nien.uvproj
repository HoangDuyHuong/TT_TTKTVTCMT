# Keil uVision project dong_ho_van_nien.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: dong_ho_van_nien
  c flags: Optimize=8 SizeSpeed=1
