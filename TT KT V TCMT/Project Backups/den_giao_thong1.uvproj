# Keil uVision project den_giao_thong1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: den_giao_thong1
  c flags: Optimize=8 SizeSpeed=1
