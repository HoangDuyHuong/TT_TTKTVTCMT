# Keil uVision project I2C_COM.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: I2C_COM +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: DS1302.h main.c ThreeWiresProtocol.h LED7Seg_OnKit.h Calendar_OnKit.h base_lib.h
