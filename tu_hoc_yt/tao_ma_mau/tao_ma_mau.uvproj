# Keil uVision project tao_ma_mau.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: tao_ma_mau
  c flags: Optimize=8 SizeSpeed=1
