# Keil uVision project dong_ho_real_time_th.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: dong_ho_real_time_th +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
    ./Bai019 (1)/Bai019/Lib/: LCD4.c Delay.c Soft_I2C.c Rtc_Ds1307.c
